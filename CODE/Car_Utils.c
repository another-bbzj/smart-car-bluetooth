/*********************************************************************************************************************
* 文件名称          Car_Utils.c
* 功能说明          整车通用工具函数的实现，属于"无外设依赖"的基础模块。
*
*                   本文件包含的函数：
*                   · Car_AbsFloat       —— 浮点绝对值
*                   · Car_ClampFloat     —— 对称限幅 [-limit, +limit]
*                   · Car_ReadU16BE      —— 大端 16 位无符号读取
*                   · Car_ReadU32BE      —— 大端 32 位无符号读取
*                   · Car_ReadI16BE      —— 大端 16 位有符号读取
*
*                   这些函数被控制层（Car_Core）、协议层（Car_Vision）和速度环（Car_PID）共同使用。
*                   本文件只做纯计算，不读写任何寄存器，因此可以被中断和主循环同时调用。
*
* 修改记录
* 日期              作者                备注
* 2026-11-12                            从 Car_Core/Car_Vision/Car_PID 抽取公共工具
********************************************************************************************************************/
#include "Car_Utils.h"

/*-------------------------------------------------------------------------------------------------------------------
 * 函数名称    Car_AbsFloat
 * 功能说明    求浮点数的绝对值：负数取反，非负数原样返回。
 * 用法        速度环、堵转判断、方向异常判断中凡是需要"只看大小不看符号"的地方都可以调用。
 * 参数说明    x —— 任意浮点数
 * 返回说明    |x|
 * 示例        float a = Car_AbsFloat(-80.0f);   // a = 80.0f
 * 备注        不处理 NaN/Inf；本项目的输入来自可控的整数换算和 PID 输出。
 *-------------------------------------------------------------------------------------------------------------------*/
float Car_AbsFloat(float x)
{
    return (x < 0.0f) ? -x : x;
}

/*-------------------------------------------------------------------------------------------------------------------
 * 函数名称    Car_ClampFloat
 * 功能说明    把数值限制在 [-limit, +limit] 区间内：超过上界取 +limit，低于下界取 -limit。
 * 用法        轮速目标限幅、参考斜坡步长限制、PID 积分与输出限幅。
 * 参数说明    x     —— 待限幅的数值
 *             limit —— 限幅绝对值，必须为非负数
 * 返回说明    限幅后的数值
 * 示例        float t = Car_ClampFloat(300.0f, 180.0f);   // t = 180.0f
 * 备注        先判正界再判负界，NaN 与任何数比较都为假，因此 NaN 会原样返回。
 *-------------------------------------------------------------------------------------------------------------------*/
float Car_ClampFloat(float x, float limit)
{
    if (x > limit) {
        return limit;
    }
    if (x < -limit) {
        return -limit;
    }
    return x;
}

/*-------------------------------------------------------------------------------------------------------------------
 * 函数名称    Car_ReadU16BE
 * 功能说明    按大端字节序（高字节在前）把 2 个字节拼成一个 16 位无符号整数。
 * 用法        蓝牙命令、视觉帧头中的长度、序号、时延等字段解析。
 * 参数说明    p —— 指向 2 字节大端数据的指针
 * 返回说明    解析出的 uint16_t
 * 示例        // p[0] = 0x00, p[1] = 0x50 -> 80
 *             uint16_t n = Car_ReadU16BE(p);
 * 备注        不检查指针边界，调用方需保证至少有 2 字节可读。
 *-------------------------------------------------------------------------------------------------------------------*/
uint16_t Car_ReadU16BE(const uint8_t *p)
{
    return (uint16_t)(((uint16_t)p[0] * 256U) + (uint16_t)p[1]);
}

/*-------------------------------------------------------------------------------------------------------------------
 * 函数名称    Car_ReadU32BE
 * 功能说明    按大端字节序把 4 个字节拼成一个 32 位无符号整数。
 * 用法        视觉帧中的会话号 session 等 32 位字段解析。
 * 参数说明    p —— 指向 4 字节大端数据的指针
 * 返回说明    解析出的 uint32_t
 * 示例        uint32_t session = Car_ReadU32BE(frame + 8);
 * 备注        由两次 Car_ReadU16BE 拼接实现，高 16 位在前。
 *-------------------------------------------------------------------------------------------------------------------*/
uint32_t Car_ReadU32BE(const uint8_t *p)
{
    return ((uint32_t)Car_ReadU16BE(p) << 16) | (uint32_t)Car_ReadU16BE(p + 2);
}

/*-------------------------------------------------------------------------------------------------------------------
 * 函数名称    Car_ReadI16BE
 * 功能说明    按大端字节序把 2 个字节解释为 16 位有符号补码整数。
 * 用法        轮速目标（左右轮 rpm）、视觉横向偏差、航向角、曲率等有符号字段解析。
 * 参数说明    p —— 指向 2 字节大端补码数据的指针
 * 返回说明    -32768 ~ 32767 的 int32_t
 * 示例        // p[0] = 0xFF, p[1] = 0xB0 -> -80
 *             int32_t rpm = Car_ReadI16BE(p);
 * 备注        最高位为 1 时按 65536 取补，返回值用 int32_t 承载便于后续比较。
 *-------------------------------------------------------------------------------------------------------------------*/
int32_t Car_ReadI16BE(const uint8_t *p)
{
    uint16_t raw = Car_ReadU16BE(p);                       /* 先按无符号读出 16 位原始值 */

    if ((raw & 0x8000U) != 0U) {                           /* 最高位为 1：负数 */
        return (int32_t)raw - 65536;
    }
    return (int32_t)raw;
}
